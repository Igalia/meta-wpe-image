FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://uinput.cfg"
