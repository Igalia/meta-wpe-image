FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://uinput.cfg \
            file://ikconfig.cfg \
"
