RDEPENDS:${PN} = ""
RRECOMMENDS:${PN} = "${PN}-proxy (>= ${PV})"

