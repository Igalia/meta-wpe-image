# nooelint: oelint.vars.autorev oelint.append.protvars.SRCREV
SRCREV:class-devupstream = "${AUTOREV}"
# nooelint: oelint.var.order.PV oelint.append.protvars.PV
PV:class-devupstream = "trunk"
