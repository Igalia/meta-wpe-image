SRCREV:class-devupstream = "${AUTOREV}"
PV:class-devupstream = "trunk"
