FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://fragment.cfg"

unset COMPATIBLE_MACHINE

