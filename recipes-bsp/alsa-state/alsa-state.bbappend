FILESEXTRAPATHS:prepend:wandboard := "${THISDIR}/${PN}/wandboard:"
FILESEXTRAPATHS:prepend:rpi := "${THISDIR}/${PN}/rpi:"
