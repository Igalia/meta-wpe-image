FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-drm-avoid-dma-buf-feedback-endless-loop.patch"

